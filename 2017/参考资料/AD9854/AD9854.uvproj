# Keil uVision project AD9854.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89LE58RD+ STC
  cpu: IRAM(0 - 0xFF) XRAM(0- 0x3FF) IROM(0 - 0x7FFF) CLOCK(25000000)
  output: AD9854 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c key.c AD9854.c AD9854.h
